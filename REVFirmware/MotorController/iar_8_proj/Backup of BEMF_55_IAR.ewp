# IAR project Backup of BEMF_55_IAR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PAC5523 PAC5523
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\pac55xx_sdk\driver; ..\pac55xx_sdk\peripheral; ..\pac55xx_sdk\boot_IAR; ..\cmsis_core
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BEMF_55_IAR.srec
  ILINK.IlinkOutputFile: BEMF_55_IAR.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/: main.c
  group 1_FirstStep
    ../src/: app_select.h bldc_hw_select.h
  group app_specific/hs_HallSensor
    ../src/: hs_functions.c hs_peripheral_init.c hs_state_machine.c
  group app_specific/rc_sensorlessRCPWM
    ../src/: rc_def.h rc_functions.c rc_peripheral_init.c rc_state_machine.c
  group app_specific/sl_sensorless
    ../src/: sl_functions.c sl_peripheral_init.c sl_state_machine.c
  group bldc_common
    ../src/: beep_notes.c bldc_common.c diag_tunes.c fix16.c init.c pid.c SineWaveLUT.c uart.c
  group cmsis
    ../cmsis_core/: core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h
  group drivers
    ../pac55xx_sdk/driver/: pac5xxx_driver_adc.c pac5xxx_driver_adc.h pac5xxx_driver_config.h pac5xxx_driver_gpio.c pac5xxx_driver_gpio.h pac5xxx_driver_memory.h pac5xxx_driver_socbridge.c pac5xxx_driver_socbridge.h pac5xxx_driver_system.c pac5xxx_driver_system.h pac5xxx_driver_tile.h pac5xxx_driver_tile_socbridge.c pac5xxx_driver_timer.c pac5xxx_driver_timer.h pac5xxx_driver_uart.c pac5xxx_driver_uart.h
  group includes
    ../src/: bldc_common.h fix16.h motordef.h pid.h state_machine.h uart.h version.h
  group ISR_Handlers
    ../src/: isr_adc.c isr_Stubs.c isr_TimerA.c isr_TimerB.c isr_TimerC.c isr_TimerD.c
  group peripherals
    ../pac55xx_sdk/peripheral/: pac5xxx.h pac5xxx_adc.h pac5xxx_can.h pac5xxx_crc.h pac5xxx_gp_timers.h pac5xxx_gpio.h pac5xxx_i2c.h pac5xxx_memory.h pac5xxx_rtc.h pac5xxx_scc.h pac5xxx_ssp.h pac5xxx_tile_driver_manager.h pac5xxx_tile_power_manager.h pac5xxx_tile_signal_manager.h pac5xxx_tile_system_manager.h pac5xxx_timers.h pac5xxx_uart.h pac5xxx_wwdt.h
  group startup
    ../pac55xx_sdk/boot_IAR/: startup_pac55xx_iar.s
